# Keil uVision project MainBoard_Control.uvprojx, settings and files
target MainBoard_Control (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\433M;..\HARDWARE\MOTOR;..\HARDWARE\STEER;..\HARDWARE\Public_Value;..\HARDWARE\ADC;..\HARDWARE\IWDG;..\HARDWARE\TEST
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/433M/: 433m.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/STEER/: steer.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/IWDG/: wdg.c
    ../HARDWARE/TEST/: test.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_sdio.c stm32f10x_wwdg.c
  group README
    ../: README.TXT
